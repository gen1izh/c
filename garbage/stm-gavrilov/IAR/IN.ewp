# IAR project IN.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105K6 STM8S105K6
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: D:\06_svn\freelance\stm-gavrilov\target\libs\Libraries\STM8S_StdPeriph_Driver\inc; D:\06_svn\freelance\stm-gavrilov\target\libs\Libraries\STM8S_StdPeriph_Driver\src; D:\06_svn\freelance\stm-gavrilov\IAR\; D:\06_svn\freelance\stm-gavrilov\IAR\control_panel_manager; D:\06_svn\freelance\stm-gavrilov\IAR\devices\uart; D:\06_svn\freelance\stm-gavrilov\IAR\devices\lcd; D:\06_svn\freelance\stm-gavrilov\IAR\devices\lcd\menu
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c stm8s_it.c
  group control_panel_manager
    control_panel_manager/: cpm.c data.h
  group devices/lcd
    devices/lcd/: LCDDriver.c LCDDriverMTC_S16204X.c menu_pult.c
    devices/lcd/menu/: menu_level1.c menu_level1.h menu_level2.c menu_level2.h menu_level3.c menu_level3.h menu_level4.c menu_level4.h
  group devices/uart
    devices/uart/: uart.c
  group Drivers
    ./: MyLib.c
    ../target/libs/Libraries/STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_gpio.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c
    ../target/libs/Libraries/STM8S_StdPeriph_Driver/inc/: stm8s_uart2.h
  group proto
    proto/: proto_routines.c
