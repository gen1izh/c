# IAR project Led-01.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: D:\06_svn\freelance\stm-gavrilov\target\libs\Libraries\STM8_TouchSensing_Driver\inc; D:\06_svn\freelance\stm-gavrilov\target\libs\inc; D:\06_svn\freelance\stm-gavrilov\target\libs\Libraries\STM8S_StdPeriph_Driver\inc; D:\06_svn\freelance\stm-gavrilov\target\devices\buttons; D:\06_svn\freelance\stm-gavrilov\target\devices\lcd\Headers
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Led-01.hex
  ILINK.IlinkOutputFile: yyy.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c stm8s_it.c
  group devices/button
    devices/buttons/: button.c
  group devices/lcd
    devices/lcd/Headers/: LCDDefine.h
    devices/lcd/Sources/: LCDDriver.c LCDDriverMTC_S16204X.c
  group libs/inc
    libs/inc/: parameter.h stm8_tsl_conf.h stm8s.h stm8s_conf.h stm8s_it.h stm8s_type.h
  group libs/STM8S_StdPeriph_Driver
    libs/Libraries/STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_clk.c stm8s_gpio.c stm8s_tim3.c stm8s_tim4.c stm8s_uart2.c
    libs/Libraries/STM8S_StdPeriph_Driver/inc/: stm8s_adc1.h stm8s_clk.h stm8s_gpio.h stm8s_tim3.h stm8s_tim4.h stm8s_uart2.h
